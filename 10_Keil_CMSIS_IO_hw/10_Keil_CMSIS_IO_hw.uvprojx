# Keil uVision project 10_Keil_CMSIS_IO_hw.uvprojx, settings and files
target tm4c1294 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 10_Keil_CMSIS_IO_hw
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c GPIO_Init.h GPIO_Init.c delay.h delay.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
