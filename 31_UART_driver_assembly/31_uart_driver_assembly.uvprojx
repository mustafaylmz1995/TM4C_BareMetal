# Keil uVision project 31_uart_driver_assembly.uvprojx, settings and files
target tm4c1294 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 31_UART_driver_assembly
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group app
    ./: main.s main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
